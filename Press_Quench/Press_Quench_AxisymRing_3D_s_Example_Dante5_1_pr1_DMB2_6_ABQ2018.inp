*Heading
** Job name: Press_Quench_Example_s Model name: Press_Quench_Example
** Generated by: Abaqus/CAE 2018
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Bottom_Die
*Node
      1,   42.9852638,          -1.,    1.1256088
      2,          43.,          -1.,           0.
      3,          43.,          -5.,           0.
      4,   42.9852638,          -5.,    1.1256088
      5,   42.9852638,          -1.,   -1.1256088
      6,          43.,           0.,           0.
      7,   42.9852638,           0.,   -1.1256088
      8,   56.9804688,          -1.,  -1.49208605
      9,          57.,          -1.,           0.
     10,          57.,          -5.,           0.
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*Element, type=R3D4
1,  1, 35, 44,  4
2, 35, 36, 43, 44
3, 36, 37, 42, 43
4, 37, 38, 41, 42
5, 38, 39, 40, 41
6, 39,  2,  3, 40
 7,  5, 45, 54,  7
 8, 45, 46, 53, 54
 9, 46, 47, 52, 53
10, 47, 48, 51, 52
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*Node
   1547,   49.9828644,          -1.,  -1.30884743
*Nset, nset=Bottom_Die-RefPt_, internal
1547,
*Elset, elset=Bottom_Die, generate
    1,  1544,     1
*End Part
**
*Part, name=Expander
*Node
      1,   38.9866371,           3.,  -1.02090096
      2,   38.9866371,           3.,   1.02090096
      3,          35.,           3.,           0.
      4,   34.9880066,           3.,  0.916193187
      5,   34.9880066,           3., -0.916193187
      6,   38.9866371,          57.,  -1.02090096
      7,   38.9866371,          57.,   1.02090096
      8,          40.,          57.,           0.
      9,   39.9862938,          57.,   1.04707789
     10,   39.9862938,          57.,  -1.04707789
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*Element, type=R3D4
1,  1, 33, 42,  5
2, 33, 34, 41, 42
3, 34, 35, 40, 41
4, 35, 36,  3, 40
5, 36, 37, 45,  3
6, 37, 38, 44, 45
7, 38, 39, 43, 44
8, 39,  2,  4, 43
 9,  6, 46, 55, 10
10, 46, 47, 54, 55
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*Node
   3955,          40.,          30., -4.8985872e-15
*Nset, nset=Expander-RefPt_, internal
3955,
*Elset, elset=Expander, generate
    1,  3952,     1
*End Part
**
*Part, name=Ring_3deg_Slice
*Node
      1,   58.7194176,           0.,  -3.07735419
      2,   58.7999992,           0.,           0.
      3,   58.7194176,           0.,   3.07735419
      4,   41.2000008,           0.,           0.
      5,   41.1435356,           0.,   2.15624142
      6,   41.1435356,           0.,  -2.15624142
      7,   58.7999992,   1.20000005,           0.
      8,   41.2000008,   1.20000005,           0.
      9,   41.1435356,   1.20000005,  -2.15624142
     10,   58.7194176,   1.20000005,  -3.07735419
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*Element, type=C3D8R
  1,  159, 1510, 6363, 1340,    1,   49, 1187,   90
  2, 1510, 1511, 6364, 6363,   49,   50, 1188, 1187
  3, 1511,  170, 6365, 6364,   50,    2, 1189, 1188
  4,  170, 1520, 6366, 6365,    2,   51, 1190, 1189
  5, 1520, 1525, 6367, 6366,   51,   52, 1191, 1190
  6, 1525,  165, 1425, 6367,   52,    3,   53, 1191
  7, 1340, 6363, 6368, 1341,   90, 1187, 1192,   89
  8, 6363, 6364, 6369, 6368, 1187, 1188, 1193, 1192
  9, 6364, 6365, 6370, 6369, 1188, 1189, 1194, 1193
 10, 6365, 6366, 6371, 6370, 1189, 1190, 1195, 1194
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*Nset, nset=Set-4, generate
     1,  15407,      1
*Elset, elset=Set-4, generate
     1,  12600,      1
*Elset, elset=ALLELEMENTS, generate
     1,  12600,      1
** Section: Section-1
*Solid Section, elset=Set-4, controls=EC-1, material=S41XX
,
*Hourglass Stiffness
225., , 0., 0.
*End Part
**
*Part, name=Top_Die
*Node
      1,   56.9804688,          61.,  -1.49208605
      2,          57.,          61.,           0.
      3,          57.,          60.,           0.
      4,   56.9804688,          60.,  -1.49208605
      5,   56.9804688,          61.,   1.49208605
      6,          57.,          65.,           0.
      7,   56.9804688,          65.,   1.49208605
      8,   42.9852638,          61.,    1.1256088
      9,          43.,          61.,           0.
     10,          43.,          60.,           0.
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*Element, type=R3D4
1,  1, 35, 44,  4
2, 35, 36, 43, 44
3, 36, 37, 42, 43
4, 37, 38, 41, 42
5, 38, 39, 40, 41
6, 39,  2,  3, 40
 7,  5, 45, 54,  7
 8, 45, 46, 53, 54
 9, 46, 47, 52, 53
10, 47, 48, 51, 52
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*Node
   1547,   49.9828644,          61.,  -1.30884743
*Nset, nset=Top_Die-RefPt_, internal
1547,
*Elset, elset=Top_Die, generate
    1,  1544,     1
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Bottom_Die-1, part=Bottom_Die
*End Instance
**
*Instance, name=Expander-1, part=Expander
*End Instance
**
*Instance, name=Ring_3deg_Slice-1, part=Ring_3deg_Slice
*End Instance
**
*Instance, name=Top_Die-1, part=Top_Die
*End Instance
**
*Nset, nset=ALLNODES, instance=Ring_3deg_Slice-1, generate
     1,  15407,      1
*Nset, nset=A_Monitor_Node, instance=Ring_3deg_Slice-1
 48,
*Nset, nset=Bottom_Die_Ref_Point, instance=Bottom_Die-1
 1547,
*Nset, nset=Expander_Ref_Point, instance=Expander-1
 3955,
*Nset, nset=Fixed_Z_Nodes-CYS1, instance=Ring_3deg_Slice-1
    1,    6,    9,   10,   15,   16,   19,   22,   26,   29,   33,   37,   39,   42,   45,   47
   74,   75,   76,   77,   78,   79,   80,   81,   82,   83,   84,   85,   86,   87,   88,   89
   90,  112,  113,  114,  115,  116,  117,  118,  119,  120,  121,  122,  123,  124,  125,  126
  127,  128,  150,  151,  152,  153,  154,  155,  156,  157,  158,  159,  195,  196,  197,  198
  199,  200,  201,  202,  203,  204,  205,  206,  207,  208,  209,  289,  290,  291,  292,  293
  294,  295,  296,  297,  298,  299,  300,  301,  302,  303,  304,  305,  306,  307,  308,  309
  310,  311,  312,  313,  314,  315,  316,  317,  318,  319,  320,  321,  322,  323,  324,  325
  326,  327,  328,  329,  330,  331,  332,  333,  334,  335,  336,  337,  338,  339,  340,  341
  342,  343,  344,  345,  466,  467,  468,  469,  470,  471,  472,  473,  474,  475,  476,  477
  478,  479,  480,  481,  482,  483,  484,  485,  486,  487,  488,  489,  490,  491,  492,  493
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*Nset, nset=Fixed_Z_Nodes_CYS2, instance=Ring_3deg_Slice-1
    3,    5,   11,   12,   13,   14,   23,   24,   27,   28,   31,   34,   35,   40,   44,   48
   53,   54,   55,   56,   57,   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,   68
   69,  131,  132,  133,  134,  135,  136,  137,  138,  139,  140,  141,  142,  143,  144,  145
  146,  147,  160,  161,  162,  163,  164,  165,  166,  167,  168,  169,  180,  181,  182,  183
  184,  185,  186,  187,  188,  189,  190,  191,  192,  193,  194,  348,  349,  350,  351,  352
  353,  354,  355,  356,  357,  358,  359,  360,  361,  362,  363,  364,  365,  366,  367,  368
  369,  370,  371,  372,  373,  374,  375,  376,  377,  378,  379,  380,  381,  382,  383,  384
  385,  386,  387,  388,  389,  390,  391,  392,  393,  394,  395,  396,  397,  398,  399,  400
  401,  402,  403,  404,  523,  524,  525,  526,  527,  528,  529,  530,  531,  532,  533,  534
  535,  536,  537,  538,  539,  540,  541,  542,  543,  544,  545,  546,  547,  548,  549,  550
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*Nset, nset=Top_Die_Ref_Point, instance=Top_Die-1
 1547,
*Elset, elset=_Bottom_Die_to_Ring_SPOS, internal, instance=Bottom_Die-1, generate
  863,  1534,     1
*Surface, type=ELEMENT, name=Bottom_Die_to_Ring
_Bottom_Die_to_Ring_SPOS, SPOS
*Elset, elset=_Expander_to_Ring_SPOS, internal, instance=Expander-1
  473,  474,  475,  476,  477,  478,  479,  480,  481,  482,  483,  484,  485,  486,  487,  488
  489,  490,  491,  492,  493,  494,  495,  496,  497,  498,  499,  500,  501,  502,  503,  504
  505,  506,  507,  508,  509,  510,  511,  512,  513,  514,  515,  516,  517,  518,  519,  520
  521,  522,  523,  524,  525,  526,  527,  528,  529,  530,  531,  532,  533,  534,  535,  536
  537,  538,  539,  540,  541,  542,  543,  544,  545,  546,  547,  548,  549,  550,  551,  552
  553,  554,  555,  556,  557,  558,  559,  560,  561,  562,  563,  564,  565,  566,  567,  568
  569,  570,  571,  572,  573,  574,  575,  576,  577,  578,  579,  580,  581,  582,  583,  584
  585,  586,  587,  588,  589,  590,  591,  592,  593,  594,  595,  596,  597,  598,  599,  600
  601,  602,  603,  604,  605,  606,  607,  608,  609,  610,  611,  612,  613,  614,  615,  616
  617,  618,  619,  620,  621,  622,  623,  624,  625,  626,  627,  628,  629,  630,  631,  632
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*Surface, type=ELEMENT, name=Expander_to_Ring
_Expander_to_Ring_SPOS, SPOS
*Elset, elset=_Exposed_Surfaces_S1, internal, instance=Ring_3deg_Slice-1, generate
 3997,  4032,     1
*Elset, elset=_Exposed_Surfaces_S2, internal, instance=Ring_3deg_Slice-1
    1,    2,    3,    4,    5,    6,    7,    8,    9,   10,   11,   12,   13,   14,   15,   16
   17,   18,   19,   20,   21,   22,   23,   24,   25,   26,   27,   28,   29,   30,   31,   32
   33,   34,   35,   36,   37,   38,   39,   40,   41,   42,   43,   44,   45,   46,   47,   48
   49,   50,   51,   52,   53,   54,   55,   56,   57,   58,   59,   60,   61,   62,   63,   64
   65,   66,   67,   68,   69,   70,   71,   72,   73,   74,   75,   76,   77,   78,   79,   80
   81,   82,   83,   84,   85,   86,   87,   88,   89,   90,   91,   92,   93,   94,   95,   96
   97,   98,   99,  100,  101,  102,  103,  104,  105,  106,  107,  108,  865,  866,  867,  868
  869,  870,  871,  872,  873,  874,  875,  876,  877,  878,  879,  880,  881,  882,  883,  884
  885,  886,  887,  888,  889,  890,  891,  892,  893,  894,  895,  896,  897,  898,  899,  900
  901,  902,  903,  904,  905,  906,  907,  908,  909,  910,  911,  912,  913,  914,  915,  916
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*Elset, elset=_Exposed_Surfaces_S4, internal, instance=Ring_3deg_Slice-1
 2958, 2964, 2970, 2976, 2982, 2988, 2994, 3000, 3006, 3012, 3018, 3024, 3030, 3036, 3042, 3048
 3054, 3060, 3066, 3072, 3078, 3084, 3090, 3096, 3102, 3108, 3114, 3120, 3126, 3132, 3138, 3144
 3150, 3156, 3162, 3168, 3822, 3828, 3834, 3840, 3846, 3852, 3858, 3864, 3870, 3876, 3882, 3888
 3894, 3900, 3906, 3912, 3918, 3924, 3930, 3936, 3942, 3948, 3954, 3960, 3966, 3972, 3978, 3984
 3990, 3996, 4002, 4008, 4014, 4020, 4026, 4032
*Elset, elset=_Exposed_Surfaces_S5, internal, instance=Ring_3deg_Slice-1
  679,  680,  681,  682,  683,  684,  715,  716,  717,  718,  719,  720,  751,  752,  753,  754
  755,  756,  787,  788,  789,  790,  791,  792,  823,  824,  825,  826,  827,  828,  859,  860
  861,  862,  863,  864, 2983, 2984, 2985, 2986, 2987, 2988, 3019, 3020, 3021, 3022, 3023, 3024
 3055, 3056, 3057, 3058, 3059, 3060, 3091, 3092, 3093, 3094, 3095, 3096, 3127, 3128, 3129, 3130
 3131, 3132, 3163, 3164, 3165, 3166, 3167, 3168, 4063, 4064, 4065, 4066, 4067, 4068, 4099, 4100
 4101, 4102, 4103, 4104, 4135, 4136, 4137, 4138, 4139, 4140, 4171, 4172, 4173, 4174, 4175, 4176
 4207, 4208, 4209, 4210, 4211, 4212, 4243, 4244, 4245, 4246, 4247, 4248
*Elset, elset=_Exposed_Surfaces_S6, internal, instance=Ring_3deg_Slice-1
  649,  655,  661,  667,  673,  679,  685,  691,  697,  703,  709,  715,  721,  727,  733,  739
  745,  751,  757,  763,  769,  775,  781,  787,  793,  799,  805,  811,  817,  823,  829,  835
  841,  847,  853,  859, 4249, 4255, 4261, 4267, 4273, 4279, 4285, 4291, 4297, 4303, 4309, 4315
 4321, 4327, 4333, 4339, 4345, 4351, 4357, 4363, 4369, 4375, 4381, 4387, 4393, 4399, 4405, 4411
 4417, 4423, 4429, 4435, 4441, 4447, 4453, 4459, 4465, 4471, 4477, 4483, 4489, 4495, 4501, 4507
 4513, 4519, 4525, 4531, 4537, 4543, 4549, 4555, 4561, 4567, 4573, 4579, 4585, 4591, 4597, 4603
 4609, 4615, 4621, 4627, 4633, 4639, 4645, 4651, 4657, 4663, 4669, 4675, 4681, 4687, 4693, 4699
 4705, 4711, 4717, 4723, 4729, 4735, 4741, 4747, 4753, 4759, 4765, 4771, 4777, 4783, 4789, 4795
 4801, 4807, 4813, 4819, 4825, 4831, 4837, 4843, 4849, 4855, 4861, 4867, 4873, 4879, 4885, 4891
 4897, 4903, 4909, 4915, 4921, 4927, 4933, 4939, 4945, 4951, 4957, 4963, 4969, 4975, 4981, 4987
 4993, 4999, 5005, 5011, 5017, 5023, 5029, 5035, 5041, 5047, 5053, 5059, 5065, 5071, 5077, 5083
 5089, 5095, 5101, 5107, 5113, 5119, 5125, 5131, 5137, 5143, 5149, 5155, 5161, 5167, 5173, 5179
 5185, 5191, 5197, 5203, 5209, 5215, 5221, 5227, 5233, 5239, 5245, 5251, 5257, 5263, 5269, 5275
 5281, 5287, 5293, 5299, 5305, 5311, 5317, 5323, 5329, 5335, 5341, 5347, 5353, 5359, 5365, 5371
 5377, 5383, 5389, 5395, 5401, 5407, 5413, 5419, 5425, 5431, 5437, 5443, 5449, 5455, 5461, 5467
 5473, 5479, 5485, 5491, 5497, 5503, 5509, 5515, 5521, 5527, 5533, 5539, 5545, 5551, 5557, 5563
 5569, 5575, 5581, 5587, 5593, 5599, 5605, 5611, 5617, 5623, 5629, 5635, 5641, 5647, 5653, 5659
 5665, 5671, 5677, 5683, 5689, 5695, 5701, 5707, 5713, 5719, 5725, 5731, 5737, 5743, 5749, 5755
 5761, 5767, 5773, 5779, 5785, 5791, 5797, 5803, 5809, 5815, 5821, 5827, 5833, 5839, 5845, 5851
 5857, 5863, 5869, 5875, 5881, 5887, 5893, 5899, 5905, 5911, 5917, 5923, 5929, 5935, 5941, 5947
 5953, 5959, 5965, 5971, 5977, 5983, 5989, 5995, 6001, 6007, 6013, 6019, 6025, 6031, 6037, 6043
 6049, 6055, 6061, 6067, 6073, 6079, 6085, 6091, 6097, 6103, 6109, 6115, 6121, 6127, 6133, 6139
 6145, 6151, 6157, 6163, 6169, 6175, 6181, 6187, 6193, 6199, 6205, 6211, 6217, 6223, 6229, 6235
 6241, 6247, 6253, 6259, 6265, 6271, 6277, 6283, 6289, 6295, 6301, 6307, 6313, 6319, 6325, 6331
*Surface, type=ELEMENT, name=Exposed_Surfaces
_Exposed_Surfaces_S1, S1
_Exposed_Surfaces_S2, S2
_Exposed_Surfaces_S4, S4
_Exposed_Surfaces_S6, S6
_Exposed_Surfaces_S5, S5
*Elset, elset=_Ring_to_Bottom_Die_S2, internal, instance=Ring_3deg_Slice-1, generate
   1,  108,    1
*Elset, elset=_Ring_to_Bottom_Die_S5, internal, instance=Ring_3deg_Slice-1
  679,  680,  681,  682,  683,  684,  715,  716,  717,  718,  719,  720,  751,  752,  753,  754
  755,  756,  787,  788,  789,  790,  791,  792,  823,  824,  825,  826,  827,  828,  859,  860
  861,  862,  863,  864, 2983, 2984, 2985, 2986, 2987, 2988, 3019, 3020, 3021, 3022, 3023, 3024
 3055, 3056, 3057, 3058, 3059, 3060, 3091, 3092, 3093, 3094, 3095, 3096, 3127, 3128, 3129, 3130
 3131, 3132, 3163, 3164, 3165, 3166, 3167, 3168
*Surface, type=ELEMENT, name=Ring_to_Bottom_Die
_Ring_to_Bottom_Die_S2, S2
_Ring_to_Bottom_Die_S5, S5
*Elset, elset=_Ring_to_Expander_S2, internal, instance=Ring_3deg_Slice-1, generate
  865,  1212,     1
*Elset, elset=_Ring_to_Expander_S4, internal, instance=Ring_3deg_Slice-1
 2958, 2964, 2970, 2976, 2982, 2988, 2994, 3000, 3006, 3012, 3018, 3024, 3030, 3036, 3042, 3048
 3054, 3060, 3066, 3072, 3078, 3084, 3090, 3096, 3102, 3108, 3114, 3120, 3126, 3132, 3138, 3144
 3150, 3156, 3162, 3168, 3822, 3828, 3834, 3840, 3846, 3852, 3858, 3864, 3870, 3876, 3882, 3888
 3894, 3900, 3906, 3912, 3918, 3924, 3930, 3936, 3942, 3948, 3954, 3960, 3966, 3972, 3978, 3984
 3990, 3996, 4002, 4008, 4014, 4020, 4026, 4032
*Surface, type=ELEMENT, name=Ring_to_Expander
_Ring_to_Expander_S2, S2
_Ring_to_Expander_S4, S4
*Elset, elset=_Ring_to_Top_Die_S1, internal, instance=Ring_3deg_Slice-1, generate
 3997,  4032,     1
*Elset, elset=_Ring_to_Top_Die_S2, internal, instance=Ring_3deg_Slice-1
 3709, 3710, 3711, 3712, 3713, 3714, 3715, 3716, 3717, 3718, 3719, 3720, 3721, 3722, 3723, 3724
 3725, 3726, 3727, 3728, 3729, 3730, 3731, 3732, 3733, 3734, 3735, 3736, 3737, 3738, 3739, 3740
 3741, 3742, 3743, 3744, 3745, 3746, 3747, 3748, 3749, 3750, 3751, 3752, 3753, 3754, 3755, 3756
 3757, 3758, 3759, 3760, 3761, 3762, 3763, 3764, 3765, 3766, 3767, 3768, 3769, 3770, 3771, 3772
 3773, 3774, 3775, 3776, 3777, 3778, 3779, 3780, 3781, 3782, 3783, 3784, 3785, 3786, 3787, 3788
 3789, 3790, 3791, 3792, 3793, 3794, 3795, 3796, 3797, 3798, 3799, 3800, 3801, 3802, 3803, 3804
 3805, 3806, 3807, 3808, 3809, 3810, 3811, 3812, 3813, 3814, 3815, 3816, 4033, 4034, 4035, 4036
 4037, 4038, 4039, 4040, 4041, 4042, 4043, 4044, 4045, 4046, 4047, 4048, 4049, 4050, 4051, 4052
 4053, 4054, 4055, 4056, 4057, 4058, 4059, 4060, 4061, 4062, 4063, 4064, 4065, 4066, 4067, 4068
*Surface, type=ELEMENT, name=Ring_to_Top_Die
_Ring_to_Top_Die_S1, S1
_Ring_to_Top_Die_S2, S2
*Elset, elset=_Top_Die_to_Ring_SPOS, internal, instance=Top_Die-1, generate
  863,  1534,     1
*Surface, type=ELEMENT, name=Top_Die_to_Ring
_Top_Die_to_Ring_SPOS, SPOS
*Rigid Body, ref node=Bottom_Die-1.Bottom_Die-RefPt_, elset=Bottom_Die-1.Bottom_Die
*Rigid Body, ref node=Expander-1.Expander-RefPt_, elset=Expander-1.Expander
*Rigid Body, ref node=Top_Die-1.Top_Die-RefPt_, elset=Top_Die-1.Top_Die
*Nset, nset="_T-Ring_3deg_Slice-1-Datum csys-1", internal
Fixed_Z_Nodes-CYS1,
*Transform, nset="_T-Ring_3deg_Slice-1-Datum csys-1"
0.998629534754574,           0., -0.0523359562429444,           0.,           1.,           0.
*Nset, nset="_T-Ring_3deg_Slice-1-Datum csys-2", internal
Fixed_Z_Nodes_CYS2,
*Transform, nset="_T-Ring_3deg_Slice-1-Datum csys-2"
0.998629534754574,           0., 0.0523359562429485,           0.,           1.,           0.
*End Assembly
**
** MATERIALS
**
*Material, name=S41XX
*Density
 7.83e-06,
*Depvar
    133,
       1,   DEFWF_CARB,         Defined Nascent Carbon Weight Fraction
        2,   HARDNESS,           Total Hardness
        4,   DEFWF_NITROGEN,     Defined Nascent Nitrogen Weight Fraction
        5,   PSTRAIN,            Plastic Strain
        21,  VF_AUSTENITE,       Volume Fraction of Austenite
        34,  VF_FERRITE,         Volume Fraction of Ferrite
        47,  VF_PEARLITE,        Volume Fraction of Pearlite
        60,  VF_UBAINITE,        Volume Fraction of Upper Bainite
        73,  VF_LBAINITE,        Volume Fraction of Lower Bainite
        86,  VF_MARTENSITE,      Volume Fraction of Martensite
        99,  VF_TMARTENSITE,     Volume Fraction of Tempered Martensite
        102, WF_CARB_AUST,       Carbon Weight Fraction in Austenite
        103, WF_CARB_FERR,       Carbon Weight Fraction in Ferrite
        104, WF_CARB_PEARL,      Carbon Weight Fraction in Pearlite
        105, WF_CARB_UBAIN,      Carbon Weight Fraction in Upper Bainite
        106, WF_CARB_LBAIN,      Carbon Weight Fraction in Lower Bainite
        107, WF_CARB_MART,       Carbon Weight Fraction in Martensite
        108, WF_CARB_TMART,      Carbon Weight Fraction in Tempered Martensite
        109, DEFWF_CBDA,         Defined Carbon Weight Fraction in Carbide A
        110, DEF_CBDA_SIZE,      Defined Carbide A Size Factor
        113, DEFWF_NTDA,         Defined Nitrogen Weight Fraction in Nitride A
        114, DEF_NTDA_SIZE,      Defined Nitride A Size Factor
        117, HYDRO_PRES,         Hydrostatic Pressure
*User Material, constants=27
**Row1 (1rd:Density),(2nd:ModelType),(3rd-8th:F,P,UB,LB,M,TM)
 7.83e-06, 0.0, 0.3, 0.7, 0.0, 0.0, 0.0, 0.0
**Row2 (1rd:TM-TEMP),(2nd:Rsvd),(3rd:GS),(4th:Rsvd),(5th:Mn),(6th:Si),(7th:Ni),(8th:Cr)
             250.0,        ,       -1,         -1,        -1,      -1,     -1,   -1
**Row3 (1st:Mo),(2nd:Cu),(3rd:V),(4th:P),(5th:Nb),(6th:Al),(7th:Ti),(8th:W)
             -1,      -1,      -1,     -1,     -1,      -1,      -1,     -1
**Row4 (1st:Co),(2nd:B),(3rd:N)
           -1,       -1,     -1
**
** INTERACTION PROPERTIES
**
*Surface Interaction, name=IntProp-1
1.,
*Friction
0.,
*Surface Behavior, augmented Lagrange
**
** BOUNDARY CONDITIONS
**
** Name: BC-1 Type: Displacement/Rotation
*Boundary
Bottom_Die_Ref_Point, 1, 1
Bottom_Die_Ref_Point, 2, 2
Bottom_Die_Ref_Point, 3, 3
Bottom_Die_Ref_Point, 4, 4
Bottom_Die_Ref_Point, 5, 5
Bottom_Die_Ref_Point, 6, 6
** Name: BC-2 Type: Displacement/Rotation
*Boundary
Expander_Ref_Point, 2, 2
Expander_Ref_Point, 3, 3
Expander_Ref_Point, 4, 4
Expander_Ref_Point, 5, 5
Expander_Ref_Point, 6, 6
** Name: BC-3 Type: Displacement/Rotation
*Boundary
Top_Die_Ref_Point, 1, 1
Top_Die_Ref_Point, 3, 3
Top_Die_Ref_Point, 4, 4
Top_Die_Ref_Point, 5, 5
Top_Die_Ref_Point, 6, 6
** Name: BC-4 Type: Displacement/Rotation
*Boundary
Fixed_Z_Nodes-CYS1, 3, 3
** Name: BC-5 Type: Displacement/Rotation
*Boundary
Fixed_Z_Nodes_CYS2, 3, 3
**
** PREDEFINED FIELDS
**
** Name: Kinetics_Mode-1   Type: Field
*Initial Conditions, type=FIELD, variable=1
ALLNODES, -4.
** Name: Predefined Field-1   Type: Field
*Initial Conditions, type=FIELD, variable=12
ALLNODES, 0.
** Name: TemperatureField-1   Type: Temperature
*Initial Conditions, type=TEMPERATURE
ALLNODES, 20.
** Name: Total_CarbonWt-1   Type: Field
*Initial Conditions, type=FIELD, variable=3
ALLNODES, 0.002
**
** INTERACTIONS
**
** Interaction: Int-3
*Contact Pair, interaction=IntProp-1, type=SURFACE TO SURFACE, adjust=0.0
Ring_to_Bottom_Die, Bottom_Die_to_Ring
** Interaction: Int-4
*Contact Pair, interaction=IntProp-1, type=SURFACE TO SURFACE, adjust=0.0
Ring_to_Expander, Expander_to_Ring
** Interaction: Int-5
*Contact Pair, interaction=IntProp-1, type=SURFACE TO SURFACE, adjust=0.0
Ring_to_Top_Die, Top_Die_to_Ring
** ----------------------------------------------------------------
**
** STEP: Heating
**
*Step, name=Heating, nlgeom=NO, amplitude=STEP, inc=1000
Austenitization step
*Static
0.01, 3600., 1e-06, 3600.
**
*Temperature, file=Press_Quench_AxisymRing_3D_t_Example_Dante5_1_pr1_DMB2_6_ABQ2018, bstep=1, estep=1
**
** LOADS
**
** Name: Load-1   Type: Concentrated force
*Cload, op=NEW
Expander_Ref_Point, 1, 1.
** Name: Load-2   Type: Concentrated force
*Cload, op=NEW
Top_Die_Ref_Point, 2, -1.
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
** ----------------------------------------------------------------
**
** STEP: Carbon Map
**
*Step, name="Carbon Map", nlgeom=NO, inc=1000
Map carbon from Carburization Model
*Static
0.01, 1., 1e-06, 1.
**
*field,variable=3,input=Press_Quench_Example_cc.cbn
*Temperature, file=Press_Quench_AxisymRing_3D_t_Example_Dante5_1_pr1_DMB2_6_ABQ2018, bstep=2, estep=2
**
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
** ----------------------------------------------------------------
**
** STEP: Transfer
**
*Step, name=Transfer, nlgeom=NO, amplitude=STEP, inc=1000
Transfer from furnace to press
*Static
0.01, 10., 1e-06, 10.
**
*Temperature, file=Press_Quench_AxisymRing_3D_t_Example_Dante5_1_pr1_DMB2_6_ABQ2018, bstep=3, estep=3
**
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
** ----------------------------------------------------------------
**
** STEP: Apply Load
**
*Step, name="Apply Load", nlgeom=NO, inc=1000
Apply load to part
*Static
0.01, 1., 1e-06, 1.
**
** LOADS
** Name: Load-3   Type: Concentrated force
*Cload, op=NEW
Expander_Ref_Point, 1, 200.
** Name: Load-4   Type: Concentrated force
*Cload, op=NEW
Top_Die_Ref_Point, 2, -200.
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
** ----------------------------------------------------------------
**
** STEP: Oil Quench
**
*Step, name="Oil Quench", nlgeom=NO, amplitude=STEP, inc=1000
Press quench using oil
*Static
0.01, 900., 1e-06, 900.
**
*Temperature, file=Press_Quench_AxisymRing_3D_t_Example_Dante5_1_pr1_DMB2_6_ABQ2018, bstep=4, estep=4
**
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
** ----------------------------------------------------------------
**
** STEP: Remove Load
**
*Step, name="Remove Load", nlgeom=NO, inc=1000
Remove load from part
*Static
0.01, 1., 1e-06, 1.
**
** LOADS
**
** Name: Load-5   Type: Concentrated force
*Cload, op=NEW
Expander_Ref_Point, 1, 1.
** Name: Load-6   Type: Concentrated force
*Cload, op=NEW
Top_Die_Ref_Point, 2, -1.
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
** ----------------------------------------------------------------
**
** STEP: Cool after Quench
**
*Step, name="Cool after Quench", nlgeom=NO, amplitude=STEP, inc=1000
Cool to room temperature after quenching
*Static
0.01, 7200., 1e-06, 7200.
**
*Temperature, file=Press_Quench_AxisymRing_3D_t_Example_Dante5_1_pr1_DMB2_6_ABQ2018, bstep=5, estep=5
**
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
** ----------------------------------------------------------------
**
** STEP: Temper
**
*Step, name=Temper, nlgeom=NO, amplitude=STEP, inc=1000
Tempering step
*Static
0.01, 7200., 1e-06, 7200.
**
*Temperature, file=Press_Quench_AxisymRing_3D_t_Example_Dante5_1_pr1_DMB2_6_ABQ2018, bstep=6, estep=6
**
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
** ----------------------------------------------------------------
**
** STEP: Cool after Temper
**
*Step, name="Cool after Temper", nlgeom=NO, amplitude=STEP, inc=1000
Cool to room temperature after tempering
*Static
0.01, 7200., 1e-06, 7200.
**
*Temperature, file=Press_Quench_AxisymRing_3D_t_Example_Dante5_1_pr1_DMB2_6_ABQ2018, bstep=7, estep=7
**
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=1000
**
** FIELD OUTPUT: F-Output-1
*Output, field, frequency=2
*Node Output
NT, U
*Element Output, directions=YES
S, SDV1, SDV2, SDV4, SDV5, SDV21, SDV34, SDV47, SDV60, SDV73, SDV86, SDV99, SDV102, SDV103,
SDV104, SDV105, SDV106, SDV107, SDV108, SDV109, SDV110, SDV113, SDV114, SDV117
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
